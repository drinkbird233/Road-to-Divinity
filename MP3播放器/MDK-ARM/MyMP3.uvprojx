# Keil uVision project MyMP3.uvprojx, settings and files
target MyMP3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MyMP3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp/Es8388;../Bsp/Mp3;../Bsp/Key;../Bsp/Lcd;../Bsp/Touch;../App/Key;../App/Player;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../App/Ui/Generated;../App/Ui/Controller;../App/Ui/Port;../Middlewares/Third_Party;../Middlewares/Third_Party/lvgl
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fsmc.c i2c.c i2s.c sdio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Bsp/Es8388
    ../Bsp/Es8388/: es8388.c
  group Bsp/Mp3
    ../Bsp/Mp3/: mp3.c mp3_player.c
  group Bsp/Lcd
    ../Bsp/Lcd/: lcd.c
  group Bsp/Key
    ../Bsp/Key/: key.c
  group App/Key
    ../App/Key/: app_key.c
  group App/Player
    ../App/Player/: playlist.c settings.c player_adapter.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App/Ui/Generated
    ../App/Ui/Generated/: ui.c screens.c styles.c images.c
  group App/Ui/Assets
    ../App/Ui/Assets/Fonts/: ui_font_cn_16.c
  group App/Ui/Controller
    ../App/Ui/Controller/: ui_controller.c
  group App/Ui/Port
    ../App/Ui/Port/: lvgl_port.c
  group Middlewares/LVGL9
    ../Middlewares/Third_Party/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Middlewares/Third_Party/lvgl/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/Third_Party/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/Third_Party/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/Third_Party/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/Third_Party/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../Middlewares/Third_Party/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/Third_Party/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/Third_Party/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/Third_Party/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/Third_Party/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Middlewares/Third_Party/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../Middlewares/Third_Party/lvgl/src/drivers/evdev/: lv_evdev.c
    ../Middlewares/Third_Party/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../Middlewares/Third_Party/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../Middlewares/Third_Party/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../Middlewares/Third_Party/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
    ../Middlewares/Third_Party/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../Middlewares/Third_Party/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../Middlewares/Third_Party/lvgl/src/drivers/qnx/: lv_qnx.c
    ../Middlewares/Third_Party/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../Middlewares/Third_Party/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../Middlewares/Third_Party/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../Middlewares/Third_Party/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../Middlewares/Third_Party/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../Middlewares/Third_Party/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/Third_Party/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Middlewares/Third_Party/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/Third_Party/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/Third_Party/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Middlewares/Third_Party/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Middlewares/Third_Party/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Middlewares/Third_Party/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/Third_Party/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../Middlewares/Third_Party/lvgl/src/libs/gif/: lv_gif.c
    ../Middlewares/Third_Party/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Middlewares/Third_Party/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../Middlewares/Third_Party/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../Middlewares/Third_Party/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/Third_Party/lvgl/src/libs/libpng/: lv_libpng.c
    ../Middlewares/Third_Party/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/Third_Party/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/Third_Party/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/Third_Party/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/Third_Party/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/Third_Party/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/Third_Party/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Middlewares/Third_Party/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../Middlewares/Third_Party/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../Middlewares/Third_Party/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Middlewares/Third_Party/lvgl/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/Third_Party/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/Third_Party/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl/src/others/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/lvgl/src/others/observer/: lv_observer.c
    ../Middlewares/Third_Party/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Middlewares/Third_Party/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/Third_Party/lvgl/src/others/translation/: lv_translation.c
    ../Middlewares/Third_Party/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/Third_Party/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../Middlewares/Third_Party/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/Third_Party/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/Third_Party/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/Third_Party/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/Third_Party/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/win/: lv_win.c
  group Bsp/Touch
    ../Bsp/Touch/: xpt2046.c
software components: CMSIS:CORE 4.3.0
